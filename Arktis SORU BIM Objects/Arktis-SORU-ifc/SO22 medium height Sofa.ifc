Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-03-03T15:27:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Mar 03 15:27:34 2024 * Host: Fazi * Database: C:\Users\INTERI~1\AppData\Local\Temp\5e56cef8-4ac4-4199-8f9a-ba81f1ddb095\e625b5f4-5317-4a8f-93f1-681bafc1940e\ifc * Database version: 5507 * Database creation date: Sun Mar 03 15:27:34 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Mar 03 15:27:34 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Mar 03 15:27:34 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: SORU Sofa:SO22 medium height sofa, SORU Sofa:SO22 medium height sofa:351247
In: Level 1
Type - Material: Default Upholstery, Default Wood
Type - Pset_ManufacturerTypeInformation - Manufacturer: ARKTIS
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: SO22 medium height sofa
